options:
  parameters:
    generate_options: qt_gui
    id: sig_receive
    output_language: python
    title: signal receive
  states: {}

blocks:
- name: cf
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: code
  id: variable
  parameters:
    value: '"10"'
  states: {}
- name: codeTime
  id: variable
  parameters:
    value: '"50ms"'
  states: {}
- name: dist_main
  id: variable
  parameters:
    value: '"500cm"'
  states: {}
- name: filename_main
  id: variable
  parameters:
    value: code + "_power_rx_2.4G_sr_400k_DCauto_"+codeTime+"_" + dist_main  + "_" + timeNow
  states: {}
- name: filepath_main
  id: variable
  parameters:
    value: os.path.join(folder, filename_main)
  states: {}
- name: folder
  id: variable
  parameters:
    value: '''/home/w/Desktop/ESP_LSleep/data'''
  states: {state: disabled}
- name: folder
  id: variable
  parameters:
    value: '''/mnt/new_vol/ESP32_data'''
  states: {}
- name: rx_gain_A
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '80'
    value: '59'
  states: {}
- name: rx_gain_B
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '80'
    value: '59'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: timeNow
  id: variable
  parameters:
    value: '"01041503"'
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: filepath_main
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 400e3
    fc: cf
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: cf
    clock_source0: external
    dc_offs_enb0: auto
    dev_addr: ''
    gain0: rx_gain_A
    iq_imbal_enb0: disabled
    rx_agc0: Disabled
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_file_sink_0_1, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
